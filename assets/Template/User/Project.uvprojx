# Keil uVision project Project.uvprojx, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\Compiler5)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Clock +hex
  c flags: Optim=2 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Lib\Core;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\APP\delay;..\APP\key;..\APP\Usart;..\APP\TIMER;..\APP\OLED;..\APP\lunar;..\APP\protocol;..\APP\rtc;..\APP\ClockCore;..\APP\SystemState;..\APP\Stopwatch;..\APP\Countdown;..\APP\AnalogClock;..\APP\UI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./: main.c
  group Lib
    ../Lib/Core/: startup_stm32f10x_hd.s core_cm3.c system_stm32f10x.c stm32f10x.h
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_i2c.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c
